# Keil uVision project small_rtos.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: small_rtos +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./os/: os_rtos_malloc.c small_rtos_list.c small_rtos_hardware.c small_rtos_core.c small_rtos.asm small_rtos_main.c
